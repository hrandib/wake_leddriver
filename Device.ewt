<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\stm8\common\circularBuffer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\common\stdint.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\common\string_utils.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\common\type_traits.h</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\stm8\drivers\adc_keyboard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\drivers\am2302.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\drivers\encoder.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\drivers\s1d157xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\drivers\ssd1306.h</name>
    </file>
  </group>
  <group>
    <name>hal</name>
    <file>
      <name>$PROJ_DIR$\stm8\hal\adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\clock.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\crc.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\crc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\delay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\itc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\onewire.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\pinlist.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\stm8s.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\timers.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\hal\uart.h</name>
    </file>
  </group>
  <group>
    <name>wake</name>
    <file>
      <name>$PROJ_DIR$\stm8\wake\ledDriver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\wake\ledStrip.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\wake\relays.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\wake\switch.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8\wake\wakeBase.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.cpp</name>
  </file>
</project>


