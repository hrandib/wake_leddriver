# IAR project Device.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x0000
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: inc; stm8\hal; stm8\common; stm8\wake
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: Device.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: stm8\linker\lnkstm8s003f3_bootloader.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkExtraOptions: --redirect __intvect=ISR_TABLE
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenHeapSize: 0x0
  ICCSTM8.CCIncludePath2: stm8\common; stm8\hal; stm8\drivers; stm8\wake
  ILINK.IlinkOutputFile: Light.out
  ILINK.IlinkExtraOptions: --redirect __intvec=ISR_TABLE
  group (top)
    ./: main.cpp
  group common
    stm8/common/: stdint.h type_traits.h
  group hal
    stm8/hal/: crc.h delay.h flash.h gpio.h stm8s.h uart.h
  group wake
    stm8/wake/: bootloader.h wakeBase.h
